# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89F0541 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(32000000)
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
